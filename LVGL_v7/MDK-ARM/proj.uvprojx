# Keil uVision project proj.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proj
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,ARDUINO=111
  c misc: --gnu
  c include: ..\USER;..\ArduinoAPI;..\Core;..\Libraries
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.cpp DisplayBasic.cpp lv_port_disp.cpp lv_port_indev.cpp
  group lv_examples
    ../Libraries/: lv_ex_conf.h
    ../Libraries/lv_examples/assets/: img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_chroma_keyed.c img_cogwheel_indexed16.c img_cogwheel_rgb.c img_hand.c lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
    ../Libraries/lv_examples/src/lv_demo_benchmark/: lv_demo_benchmark.c
    ../Libraries/lv_examples/src/lv_demo_keypad_encoder/: lv_demo_keypad_encoder.c
    ../Libraries/lv_examples/src/lv_demo_printer/: lv_demo_printer.c lv_demo_printer_theme.c
    ../Libraries/lv_examples/src/lv_demo_printer/images/: lv_demo_printer_icon_bright.c lv_demo_printer_icon_eco.c lv_demo_printer_icon_hue.c lv_demo_printer_icon_pc.c lv_demo_printer_icon_tel.c lv_demo_printer_icon_wifi.c lv_demo_printer_img_btn_bg_1.c lv_demo_printer_img_btn_bg_2.c lv_demo_printer_img_btn_bg_3.c lv_demo_printer_img_btn_bg_4.c lv_demo_printer_img_cloud.c lv_demo_printer_img_copy.c lv_demo_printer_img_internet.c lv_demo_printer_img_mobile.c lv_demo_printer_img_no_internet.c lv_demo_printer_img_phone.c lv_demo_printer_img_print.c lv_demo_printer_img_printer2.c lv_demo_printer_img_ready.c lv_demo_printer_img_scan.c lv_demo_printer_img_scan_example.c lv_demo_printer_img_setup.c lv_demo_printer_img_usb.c lv_demo_printer_img_wave.c
    ../Libraries/lv_examples/src/lv_demo_stress/: lv_demo_stress.c
    ../Libraries/lv_examples/src/lv_demo_widgets/: lv_demo_widgets.c
    ../Libraries/lv_examples/src/lv_ex_get_started/: lv_ex_get_started_1.c lv_ex_get_started_2.c lv_ex_get_started_3.c
    ../Libraries/lv_examples/src/lv_ex_style/: lv_ex_style_1.c lv_ex_style_2.c lv_ex_style_3.c lv_ex_style_4.c lv_ex_style_5.c lv_ex_style_6.c lv_ex_style_7.c lv_ex_style_8.c lv_ex_style_9.c lv_ex_style_10.c lv_ex_style_11.c
  group LVGL
    ../Libraries/: lv_conf.h
    ../Libraries/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Libraries/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Libraries/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c
    ../Libraries/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Libraries/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Libraries/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../Libraries/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/TFT_ILI9488/: TFT_ILI9488.cpp
    ../Libraries/GT911/: GT911.cpp GTIIC.cpp touch.cpp
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp Stream.cpp WString.cpp WMath.cpp HardwareSerial.cpp WireBase.cpp Wire.cpp SPI.cpp Tone.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c
    ../CORE/: delay.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:DCMI 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
